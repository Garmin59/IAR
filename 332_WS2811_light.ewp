# IAR project 332_WS2811_light.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F0XX; STM32F051
  ICCARM.CCIncludePath2: D:\Ilya\Projects\332 WS2811 hew year light\IAR\system; D:\Ilya\Projects\332 WS2811 hew year light\IAR\project; D:\Ilya\Projects\332 WS2811 hew year light\IAR\CMSIS; D:\Ilya\Projects\332 WS2811 hew year light\IAR\CMSIS\inc; D:\Ilya\Projects\332 WS2811 hew year light\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: settings\stm32f051x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    project/: effects.c global.h inits.c main.c messages.c ws2811.c
    ./: messages.h
  group CMSIS
    CMSIS/: stm32f0xx_rcc.c
  group Datasheets
    ../../../../Илья/Даташиты/Микропроцессоры/STM32F0/: STM32F05 reference manual.pdf STM32F051C8.pdf
  group SYSTEM
    system/: stm32f051_it.h stm32f051_it.с.c stm32f0xx.h stm32f0xxAdd.h system_stm32f0xx.c
